## Zephyr_C/UART_ThreadQueue_CPP/Kconfig
```kconfig
source "Kconfig.zephyr"

config UART_FUNC
	bool "Enable UART function"
	default n

config LED_FUNC
	bool "Enable LED function"
	default n
```
